# Keil uVision project AppCodeProject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AppCodeProject
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin Objects\AppCodeProject.axf --output AppCodeProject.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Application Code Project
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Source Group 1
    ./: main.c sysTick_timer_config.c uart_config.c uart_config.h gpio_config.c gpio_config.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
